<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbs2_tx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1280e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>6000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga1_gain</value></param>
<param><key>value</key><value>-8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-35</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-4</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga2_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>dvbs2vcm.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>overflowqpsk_276_45.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>sweetnothing8psk_184_56.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>file</key><value>cosmic16apsk_138_89.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dvbs2_bbheader_bb</key>
<param><key>id</key><value>dvbs2_bbheader_bb_0</value></param>
<param><key>rate1_1</key><value>C4_5</value></param>
<param><key>rate1_2</key><value>C1_5_MEDIUM</value></param>
<param><key>rate1_3</key><value>C1_4</value></param>
<param><key>rate2_1</key><value>C5_6</value></param>
<param><key>rate2_2</key><value>C1_5_MEDIUM</value></param>
<param><key>rate2_3</key><value>C1_4</value></param>
<param><key>rate3_1</key><value>C8_9</value></param>
<param><key>rate3_2</key><value>C1_5_MEDIUM</value></param>
<param><key>rate3_3</key><value>C1_4</value></param>
<param><key>rate4_1</key><value>C1_4</value></param>
<param><key>rate4_2</key><value>C1_5_MEDIUM</value></param>
<param><key>rate4_3</key><value>C1_4</value></param>
<param><key>constellation1</key><value>MOD_QPSK</value></param>
<param><key>constellation2</key><value>MOD_8PSK</value></param>
<param><key>constellation3</key><value>MOD_16APSK</value></param>
<param><key>constellation4</key><value>MOD_QPSK</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize3</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize4</key><value>FECFRAME_NORMAL</value></param>
<param><key>goldcode1</key><value>0</value></param>
<param><key>goldcode2</key><value>0</value></param>
<param><key>goldcode3</key><value>0</value></param>
<param><key>goldcode4</key><value>0</value></param>
<param><key>nstreams</key><value>3</value></param>
<param><key>pilots1</key><value>PILOTS_ON</value></param>
<param><key>pilots2</key><value>PILOTS_ON</value></param>
<param><key>pilots3</key><value>PILOTS_ON</value></param>
<param><key>pilots4</key><value>PILOTS_OFF</value></param>
<param><key>rolloff</key><value>RO_0_20</value></param>
</block>
<block>
<key>dvbs2_bbscrambler_bb</key>
<param><key>id</key><value>dvbs2_bbscrambler_bb_0</value></param>
</block>
<block>
<key>dvbs2_bch_bb</key>
<param><key>id</key><value>dvbs2_bch_bb_0</value></param>
</block>
<block>
<key>dvbs2_interleaver_bb</key>
<param><key>id</key><value>dvbs2_interleaver_bb_0</value></param>
</block>
<block>
<key>dvbs2_ldpc_bb</key>
<param><key>id</key><value>dvbs2_ldpc_bb_0</value></param>
</block>
<block>
<key>dvbs2_modulator_bc</key>
<param><key>id</key><value>dvbs2_modulator_bc_0</value></param>
</block>
<block>
<key>dvbs2_physical_cc</key>
<param><key>id</key><value>dvbs2_physical_cc_0</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>vga1_gain</value></param>
<param><key>bw0</key><value>6000000</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>vga2_gain</value></param>
<param><key>args</key><value>bladerf=0,buffers=128,buflen=32768</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, ((symbol_rate * (1 + rolloff)) / 2 ) + 1e5)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"send_frame_size=65536,num_send_frames=256,master_clock_rate=" + str(samp_rate*4)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dvbs2_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>dvbs2_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>dvbs2_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_bbheader_bb_0</source_block_id><sink_block_id>dvbs2_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_bbscrambler_bb_0</source_block_id><sink_block_id>dvbs2_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_bch_bb_0</source_block_id><sink_block_id>dvbs2_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_interleaver_bb_0</source_block_id><sink_block_id>dvbs2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_ldpc_bb_0</source_block_id><sink_block_id>dvbs2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_modulator_bc_0</source_block_id><sink_block_id>dvbs2_physical_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2_physical_cc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
