options:
  parameters:
    generate_options: qt_gui
    id: dvbs2_tx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1280e6
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '200'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: dvbs2vcm.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: overflowqpsk_276_45.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: sweetnothing8psk_184_56.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: cosmic16apsk_138_89.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: dvbs2_bbheader_bb_0
  id: dvbs2_bbheader_bb
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_8PSK
    constellation3: MOD_16APSK
    constellation4: MOD_QPSK
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    framesize3: FECFRAME_NORMAL
    framesize4: FECFRAME_NORMAL
    goldcode1: '0'
    goldcode2: '0'
    goldcode3: '0'
    goldcode4: '0'
    nstreams: '3'
    pilots1: PILOTS_ON
    pilots2: PILOTS_ON
    pilots3: PILOTS_ON
    pilots4: PILOTS_OFF
    rate1_1: C4_5
    rate1_2: C1_5_MEDIUM
    rate1_3: C1_4
    rate2_1: C5_6
    rate2_2: C1_5_MEDIUM
    rate2_3: C1_4
    rate3_1: C8_9
    rate3_2: C1_5_MEDIUM
    rate3_3: C1_4
    rate4_1: C1_4
    rate4_2: C1_5_MEDIUM
    rate4_3: C1_4
    rolloff: RO_0_20
  states: {}
- name: dvbs2_bbscrambler_bb_0
  id: dvbs2_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2_bch_bb_0
  id: dvbs2_bch_bb
  parameters: {}
  states: {}
- name: dvbs2_interleaver_bb_0
  id: dvbs2_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2_ldpc_bb_0
  id: dvbs2_ldpc_bb
  parameters: {}
  states: {}
- name: dvbs2_modulator_bc_0
  id: dvbs2_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2_physical_cc_0
  id: dvbs2_physical_cc
  parameters:
    dummyframes: DUMMY_FRAMES_OFF
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0,buffers=128,buflen=32768
    bb_gain0: vga1_gain
    bw0: '8750000'
    freq0: center_freq
    gain0: vga2_gain
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, ((symbol_rate * (1 + rolloff)) / 2 ) + 1e5)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=256,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: phy-filt
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: phy-filt
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ldpc-int
  states: {}

connections:
- [blocks_file_source_0, '0', dvbs2_bbheader_bb_0, '0']
- [blocks_file_source_0_0, '0', dvbs2_bbheader_bb_0, '1']
- [blocks_file_source_0_0_0, '0', dvbs2_bbheader_bb_0, '2']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [dvbs2_bbheader_bb_0, '0', dvbs2_bbscrambler_bb_0, '0']
- [dvbs2_bbscrambler_bb_0, '0', dvbs2_bch_bb_0, '0']
- [dvbs2_bch_bb_0, '0', dvbs2_ldpc_bb_0, '0']
- [dvbs2_interleaver_bb_0, '0', dvbs2_modulator_bc_0, '0']
- [dvbs2_ldpc_bb_0, '0', virtual_sink_1, '0']
- [dvbs2_modulator_bc_0, '0', dvbs2_physical_cc_0, '0']
- [dvbs2_physical_cc_0, '0', virtual_sink_0, '0']
- [fft_filter_xxx_0, '0', blocks_throttle_0, '0']
- [fft_filter_xxx_0, '0', osmosdr_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0, '0']
- [virtual_source_1, '0', dvbs2_interleaver_bb_0, '0']

metadata:
  file_format: 1
